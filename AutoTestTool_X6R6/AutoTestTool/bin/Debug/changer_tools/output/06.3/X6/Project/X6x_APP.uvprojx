# Keil uVision project X6x_APP.uvprojx, settings and files
target X6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: X6_APP +hex
  AfterMake: ..\tool\hex2bin.exe  Objects\X6_APP.hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HT502x
  c include: ..\Src;..\BSP;..\Libraries\HT60xx_StdPeriph_Driver\src;..\Libraries\HT60xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM0\CoreSupport;..\Libraries\CMSIS\CM0\DeviceSupport;..\Libraries\HT60xx_StdPeriph_Driver;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\MemMang;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM0;..\Middlewares\FreeRTOS\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\X6_APP.sct
  group Config
    ../Middlewares/FreeRTOS/include/: FreeRTOSConfig.h
    ../Src/: includes.h
  group Src
    ../Src/: main.c main_handle.c ckb24_um_handle.c com_handle.c 24g_proto.c blue.c comm_proto.c charger.c m1_card.c emu_info.c flash_usr.c upgrade.c ht6xxx_it.c CardAuth_handle.c
  group BSP
    ../BSP/: pmu.c cmu.c rtc.c ckb24_um.c delay.c at24c0x.c emu.c fm175xx.c gun.c sc8042b.c timer.c uart.c simuart.c simspi.c simiic.c FIFO.c aes.c
  group Drivers/Lib
    ../Libraries/HT60xx_StdPeriph_Driver/src/: ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c ht501x_emu.c ht501x_keyscan.c
  group Drivers/CMSIS
    ../Libraries/CMSIS/CM0/DeviceSupport/: system_ht6xxx.c
    ../Libraries/CMSIS/CM0/CoreSupport/: core_cm0.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/Keil/ARM_CM0/: port.c
    ../Middlewares/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group Startup
    ../Libraries/Startup/Keil/: startup_ht502x.s
